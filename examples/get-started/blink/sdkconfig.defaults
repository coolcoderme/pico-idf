## examples/get-started/blink/sdkconfig.defaults
```kconfig
CONFIG_PIDF_TARGET="pico_w"
CONFIG_PIDF_BOARD="pico_w"
CONFIG_FREERTOS_SMP=y
CONFIG_LOG_DEFAULT_LEVEL=3
CONFIG_BLINK_GPIO=32
```
